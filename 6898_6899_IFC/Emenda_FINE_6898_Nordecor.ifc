Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2025-11-09T15:25:23
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - IU alternativa 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Nov 09 15:25:23 2025 * Host: MichellyManno * Database: C:\Users\miche\AppData\Local\Temp\a581a856-4505-4b39-8a4e-923e68d898bc\2abe2414-3358-4031-a3de-a879a61a3b03\ifc * Database version: 5507 * Database creation date: Sun Nov 09 15:25:22 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Nov 09 15:25:23 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Nov 09 15:25:23 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 mm
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuildingStorey: Nível:Cabeça de 8 mm, Nível 1
LongName: Nível 1; Elevation: 0 mm
Restrições(Type) - Base da elevação: Ponto base do projeto
Outros(Type) - Categoria: Níveis; Nome da família: Nível
Cotas - Cálculo da altura: 0 mm
Dados de identidade - Andar da construção: yes; Estrutural: no; Nome: Nível 1
Outros - Categoria: Níveis; Família: Nível: Cabeça de 8 mm; Família e tipo: Nível: Cabeça de 8 mm; ID de tipo: Nível: Cabeça de 8 mm; Tipo: Nível: Cabeça de 8 mm
Restrições - Elevação: 0 mm
Dados de identidade(Type) - Nome do tipo: Cabeça de 8 mm
Gráficos(Type) - Cor: 0; Espessura da linha: 1; Padrão de linha: Centro (1); Símbolo: M_Cabeça do nível - Círculo: M_Cabeça do nível - Círculo; Símbolo no final 1 padrão: no; Símbolo no final 2 padrão: yes

# IfcFlowTerminal: 6898, Emenda_FINE_6898_6899_Nordecor:6898:329165
In: Nível 1
Type - Classification: D5020200 Lighting Equipment (Uniformat); Material: Metal - Alumínio - Branco
Type - Cotas - Comprimento 01: 107.2 mm; Comprimento 02: 107.2 mm
Type - Dados - Data de atualização: 31/03/2025; Versão: 1
Type - Dados de identidade - Código de montagem: D5020200; Código Uniformat: D5020; Comentários de tipos: Emenda “L” de embutir para parede para trilho FINE acabamento branco; Contato do desenvolvedor: "contato@checkbim.com.br"; Contato do fabricante: comercial@nordecor.com.br; Descrição: Emenda “L” de embutir para parede para trilho FINE acabamento branco; Descrição de montagem: Lighting Equipment; Descrição UniFormat: Iluminação e acessórios elétricos; Desenvolvedor: "Check BIM"; Fabricante: Nordecor; Garantia: 2 anos; IP: 20; Localização: Camboriú-SC / Brasil; Modelo: 6898; Nome do tipo: 6898; Nota-chave: 26 50 00; Número MasterFormat: 26 51 00; Número OmniClass: 23.80.70.11; Tipo de imagem: Imagem raster: 6898.jpg; Tipo de luminária: Acessório / Accessory; Título MasterFormat: Interior Lighting; Título OmniClass: Luminaries for Internal Lighting; URL: https://nordecor.com.br; URL do desenvolvedor: https://checkbim.com.br/; URL do produto: https://nordecor.com.br/produto/emenda-l-p-parede-de-embutir-p-trilho-skaly/
Type - Estrutural - Peso da luminária: 0
Type - Gráficos - Simbologia: Imagem raster: 6898 2D.png
Type - Materiais e acabamentos - Emenda "L": Metal - Alumínio - Branco
Type - Outros - Categoria: Luminárias; Branco: yes; Nome da família: Emenda_FINE_6898_6899_Nordecor; Preto: no
Type - Restrições - Elevação-padrão: 1219.2 mm
Type - Visibilidade - 2D: yes
Pset_DistributionFlowElementCommon - Reference: 6898; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Nordecor
Cotas - Área: 0.0071034 m2; Volume: 0.0000165095 m3
Dados de identidade - Marca: 1
Elétrico - Iluminação - Calcular coeficiente de utilização: no
Fase - Fase criada: Construção nova
Outros - Família: Emenda_FINE_6898_6899_Nordecor: 6898; Família e tipo: Emenda_FINE_6898_6899_Nordecor: 6898; ID de tipo: Emenda_FINE_6898_6899_Nordecor: 6898; Tipo: Emenda_FINE_6898_6899_Nordecor: 6898
Restrições - Elevação do nível: 0 mm; Hospedeiro: Nível : Nível 1; Nível: Nível: Nível 1; Nível de tabela: Nível: Nível 1
